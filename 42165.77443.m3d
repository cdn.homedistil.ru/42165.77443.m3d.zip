# KOMPAS-3D part (42165.77443.m3d)

Model tree:
1. Эскиз:1
2. Операция вращения:1
     Угол 1 = 360
